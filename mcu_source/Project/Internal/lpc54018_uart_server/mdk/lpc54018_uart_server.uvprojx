# Keil uVision project lpc54018_uart_server.uvprojx, settings and files
target lpc54608 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54608J512ET180 NXP
  pack: NXP.LPC54608_DFP.10.0.3
  cpu: IRAM(0x04000000,0x8000) IRAM2(0x20000000,0x028000) IROM(0x00000000,0x080000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpc54608_uart_server +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c define: LPC54608 RTT
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\startup\lib;..\..\..\..\Libraries\drivers_lpc\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\src;..\..\..\..\Libraries\utilities\structures;..\..\..\..\Libraries\utilities\chusb\inc;..\src\config;..\..\..\..\Libraries\utilities\rtthread\include;..\..\..\..\Libraries\utilities\rtthread\components\finsh;..\..\..\..\Libraries\utilities\rtthread\components\drivers\include;..\..\..\..\Libraries\utilities\rtthread\components\utilities\ulog;..\..\..\..\Libraries\utilities\rtthread\components\drivers\include
  asm define: XIP_IMAGE,W25Q128JVFM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  link misc: --predefine="-DXIP_IMAGE"
  group startup_lpc54608
    ../../../../Libraries/startup/lib/lpc54018/: keil_lib_power.lib
    ../../../../Libraries/startup/src/: system_LPC54608.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC54S608.s
  group startup_lpc54018
    ../../../../Libraries/startup/src/: system_LPC54018.c
    ../../../../Libraries/startup/src/mdk/: startup_LPC54018.s
    ../../../../Libraries/startup/lib/lpc54018/: keil_lib_power.lib
  group user
    ../src/: main.c usbd_thread.c mesh_cmd.c uart_bridge.c uart_bridge_support.c led_thread.c
  group drivers_lpc
    ../../../../Libraries/drivers_lpc/src/: dma.c common.c gpio.c uart.c spifi.c syscon.c ctimer.c
  group chusb
    ../../../../Libraries/utilities/chusb/src/: usbd.c usbd_cdc.c usbd_composite .c usbd_descriptor.c usbd_hid.c usbd_lpc_driver_hs.c usbd_msc.c usbd_lpc_driver.c
  group chusb\vsc
    ../../../../Libraries/utilities/chusb/src/vsc/: usbd_cp210x.c usbd_digi_serial.c
  group config
    ../src/config/: usbd_config.h rtconfig.h
  group rtthread\kernel
    ../../../../Libraries/utilities/rtthread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtthread\finsh
    ../../../../Libraries/utilities/rtthread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group rtthread\libcpu\arm\cortex-m4
    ../../../../Libraries/utilities/rtthread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../../../Libraries/utilities/rtthread/libcpu/arm/common/: showmem.c
  group rtthread\bsp\lpc546xx
    ../../../../Libraries/utilities/rtthread/bsp/lpc546xx/: drv_uart.c
  group rtthread\ulog
    ../../../../Libraries/utilities/rtthread/components/utilities/ulog/: ulog.c
    ../../../../Libraries/utilities/rtthread/components/utilities/ulog/backend/: console_be.c
  group rthread\drivier
    ../../../../Libraries/utilities/rtthread/components/drivers/serial/: serial.c
    ../../../../Libraries/utilities/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
target lpc54018 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54018JET180 NXP
  pack: NXP.LPC54018_DFP.10.0.4
  cpu: IRAM(0x00000000,0x030000) IRAM2(0x20000000,0x028000) XRAM(0x40100000,0x2000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lpc54018_uart_server +hex
  AfterMake: fromelf --bincombined -o "$L@L.bin" "#L"
  c define: LPC54608 RTT
  c misc: --c99
  c include: as above
  asm define: W25Q128JVFM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT6: RAM 0x40100000 size 0x2000
  memory RVCT9: RAM 0x18000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x28000
  link misc: --predefine="-DXIP_IMAGE"
